Commit message: fixed lower bound

File: lbr_description/urdf/med14.urdf (robot description, URDF)
Before this commit: robot med14, 8 links, 7 joints
Joints:
- joint A7: limit lower=0.0 upper=3.054326 effort=100 velocity=2.35619449 -> lower=-3.054326 upper=3.054326 effort=100 velocity=2.35619449
